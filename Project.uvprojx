# Keil uVision project Project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: APM32F103C8 Geehy
  pack: Geehy.APM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\LIB;.\LIB\inc;.\USER;.\USER\HARDWARE\TIM;.\USER\HARDWARE\GPIO;.\USER\HARDWARE\USART;.\USER\DRIVE\TIM_ISR;.\USER\DRIVE\OLED;.\USER\DRIVE\DHT11;.\USER\sys;.\NET\cJSON;.\USER\DRIVE\SHT30;.\USER\TY_SDK
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c delay.c
  group HARDWARE
    ./USER/HARDWARE/TIM/: TIM.c
    ./USER/HARDWARE/GPIO/: GPIO.c
    ./USER/HARDWARE/USART/: UART.c
  group DRIVE
    ./USER/DRIVE/TIM_ISR/: TIM_ISR.c
    ./USER/DRIVE/OLED/: OLED.c
    ./USER/DRIVE/SHT30/: SHT30.c
  group LIB
    ./LIB/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
    ./LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STARTUP
    ./LIB/STARTUP/: startup_stm32f10x_md.s
  group sys
    ./USER/sys/: sys.c
  group NET
    ./NET/cJSON/: cJSON.c
  group TY_SDK
    ./USER/TY_SDK/: mcu_api.c protocol.c system.c
